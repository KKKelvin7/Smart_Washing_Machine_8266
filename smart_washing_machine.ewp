# IAR project smart_washing_machine.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; NDEBUG; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; EW_MAX_SURFACE_CACHE_SIZE=0x200000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_DOUBLE_BUFFER=1; FSL_RTOS_FREE_RTOS; USE_RTOS; EW_USE_FREE_RTOS=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; USB_STACK_FREERTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.PreInclude: source\app_preinclude.h
  ICCARM.CCIncludePath2: board; source; source/common_drivers; source/demo_wm; source/demo_rgb; source/demo_dim; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; component/kv; component/kv/include; doc; drivers; emgui; emgui/GeneratedCode; emgui/RGB565; emgui/RTE; emgui/TargetSpecific; emgui/TLSF; lwip/port; lwip/port/arch; lwip/src; lwip/src/include; lwip/src/include/compat/posix; lwip/src/include/compat/posix/arpa; lwip/src/include/compat/posix/net; lwip/src/include/compat/posix/sys; lwip/src/include/compat/stdc; lwip/src/include/lwip; lwip/src/include/lwip/apps; lwip/src/include/lwip/priv; lwip/src/include/lwip/prot; lwip/src/include/netif; lwip/src/include/netif/ppp; lwip/src/include/netif/ppp/polarssl; sdmmc/inc; sdmmc/port; src; startup; touchpanel; utilities; xip; linkkit; mbedtls\include\mbedtls; mbedtls\include; mbedtls\port\ksdk; usb/include; usb/osa; usb/phy; usb/device; CMSIS; c-sdk\atm; c-sdk\certs; c-sdk\dev_model; c-sdk\dev_sign; c-sdk\infra; c-sdk\mqtt; c-sdk\wrappers; c-sdk\wrappers\external_libs; amazon-freertos\include; ESP8266
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: board; source; 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD; 43xxx_wifi/WICED/WWD; 43xxx_wifi/WICED/WWD/include; 43xxx_wifi/WICED/WWD/include/RTOS; 43xxx_wifi/WICED/WWD/include/network; 43xxx_wifi/WICED/WWD/include/platform; 43xxx_wifi/WICED/WWD/internal; 43xxx_wifi/WICED/WWD/internal/bus_protocols; 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO; 43xxx_wifi/WICED/WWD/internal/chips/4343W; 43xxx_wifi/WICED/network/LwIP/WWD; 43xxx_wifi/WICED/platform; 43xxx_wifi/WICED/platform/MCU; 43xxx_wifi/WICED/platform/MCU/LPC; 43xxx_wifi/WICED/platform/include; 43xxx_wifi/include; 43xxx_wifi/platforms/MURATA_TYPE1DX; CMSIS; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; doc; drivers; lwip/port; lwip/port/arch; lwip/src; lwip/src/include; lwip/src/include/compat/posix; lwip/src/include/compat/posix/arpa; lwip/src/include/compat/posix/net; lwip/src/include/compat/posix/sys; lwip/src/include/compat/stdc; lwip/src/include/lwip; lwip/src/include/lwip/apps; lwip/src/include/lwip/priv; lwip/src/include/lwip/prot; lwip/src/include/netif; lwip/src/include/netif/ppp; lwip/src/include/netif/ppp/polarssl; sdmmc/inc; sdmmc/port; src; startup; utilities; xip; WiFi_ESP8266\ESP_AT_Lib\src\include\esp; WiFi_ESP8266\ESP_AT_Lib\src\include\system
  OBJCOPY.OOCOutputFile: smart_washing_machine.srec
  ILINK.IlinkOutputFile: smart_washing_machine.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; PRINTF_FLOAT_ENABLE=1; EW_MAX_SURFACE_CACHE_SIZE=0x200000; EW_MAX_GLYPH_SURFACE_WIDTH=256; EW_MAX_GLYPH_SURFACE_HEIGHT=256; EW_USE_DOUBLE_BUFFER=1; FSL_RTOS_FREE_RTOS; USE_RTOS; EW_USE_FREE_RTOS=1; EW_SURFACE_ROTATION=0; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; WIFI_WICED; MBEDTLS_CONFIG_FILE="ksdk_mbedtls_config.h"; USB_STACK_FREERTOS
  ICCARM.PreInclude: C:\Users\nxf65135\Desktop\RT1050\smart_washing_machine-master-8266\source\app_preinclude.h
  ICCARM.CCIncludePath2: board; source; CMSIS; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; device; doc; drivers; src; startup; utilities; xip; c-sdk; c-sdk\atm; c-sdk\dev_model; c-sdk\dev_sign; c-sdk\infra; c-sdk\mqtt; c-sdk\wrappers; c-sdk\wrappers\external_libs; ESP8266; emgui\GeneratedCode; emgui\RGB565; emgui\RTE; emgui\TargetSpecific; emgui\TLSF; emgui; mbedtls\port\ksdk; source\common_drivers; source\demo_wm; utilities; mbedtls; mbedtls\include; touchpanel; component\kv\include; usb\include; usb\osa; usb\device; usb\phy
  ICCARM.CCOptLevel: 1
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: board; source; 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD; 43xxx_wifi/WICED/WWD; 43xxx_wifi/WICED/WWD/include; 43xxx_wifi/WICED/WWD/include/RTOS; 43xxx_wifi/WICED/WWD/include/network; 43xxx_wifi/WICED/WWD/include/platform; 43xxx_wifi/WICED/WWD/internal; 43xxx_wifi/WICED/WWD/internal/bus_protocols; 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO; 43xxx_wifi/WICED/WWD/internal/chips/4343W; 43xxx_wifi/WICED/network/LwIP/WWD; 43xxx_wifi/WICED/platform; 43xxx_wifi/WICED/platform/MCU; 43xxx_wifi/WICED/platform/MCU/LPC; 43xxx_wifi/WICED/platform/include; 43xxx_wifi/include; 43xxx_wifi/platforms/MURATA_TYPE1DX; CMSIS; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; device; doc; drivers; lwip/port; lwip/port/arch; lwip/src; lwip/src/include; lwip/src/include/compat/posix; lwip/src/include/compat/posix/arpa; lwip/src/include/compat/posix/net; lwip/src/include/compat/posix/sys; lwip/src/include/compat/stdc; lwip/src/include/lwip; lwip/src/include/lwip/apps; lwip/src/include/lwip/priv; lwip/src/include/lwip/prot; lwip/src/include/netif; lwip/src/include/netif/ppp; lwip/src/include/netif/ppp/polarssl; sdmmc/inc; sdmmc/port; src; startup; utilities; xip
  group 43xxx_wifi/app
    43xxx_wifi/app/: test_scan.c wlanif_add.c
  group 43xxx_wifi/include
    43xxx_wifi/include/: wiced_resource.h
  group 43xxx_wifi/internal
    43xxx_wifi/internal/: wifi.c
  group 43xxx_wifi/platforms/MURATA_TYPE1DX
    43xxx_wifi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group 43xxx_wifi/WICED
    43xxx_wifi/WICED/: generated_mac_address.txt
  group 43xxx_wifi/WICED/network/LwIP/WWD
    43xxx_wifi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group 43xxx_wifi/WICED/platform
    43xxx_wifi/WICED/platform/: platform_toolchain.h
  group 43xxx_wifi/WICED/platform/include
    43xxx_wifi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU
    43xxx_wifi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group 43xxx_wifi/WICED/platform/MCU/LPC
    43xxx_wifi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU/LPC/WWD
    43xxx_wifi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    43xxx_wifi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group 43xxx_wifi/WICED/WWD
    43xxx_wifi/WICED/WWD/: wwd.h wwd_wiced.h
  group 43xxx_wifi/WICED/WWD/include
    43xxx_wifi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group 43xxx_wifi/WICED/WWD/include/network
    43xxx_wifi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group 43xxx_wifi/WICED/WWD/include/platform
    43xxx_wifi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group 43xxx_wifi/WICED/WWD/include/RTOS
    43xxx_wifi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group 43xxx_wifi/WICED/WWD/internal
    43xxx_wifi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols
    43xxx_wifi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group 43xxx_wifi/WICED/WWD/internal/chips/4343W
    43xxx_wifi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_clm_mfg.h 4343WA1_mfg.h chip_constants.h chip_resources.c chip_resources.h wwd_ap.c wwd_chip_specific_functions.c
  group amazon-freertos/FreeRTOS
    amazon-freertos/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    amazon-freertos/FreeRTOS/portable/: fsl_tickless_generic.h fsl_tickless_systick.c heap_4.c port.c portasm.s portmacro.h readme.txt
  group amazon-freertos/include
    amazon-freertos/include/: deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h threading_alt.h timers.h
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group c-sdk/atm
    c-sdk/atm/: at_api.c at_api.h at_conn_mbox.c at_conn_mbox.h at_conn_mgmt.c at_conn_mgmt.h at_parser.c at_parser.h at_tcp.c at_wrapper.h
  group c-sdk/certs
    c-sdk/certs/: root_ca.c
  group c-sdk/dev_model
    c-sdk/dev_model/: dev_model_api.h dm_api.c dm_client.c dm_client.h dm_client_adapter.c dm_client_adapter.h dm_cota.c dm_cota.h dm_fota.c dm_fota.h dm_intf.h dm_ipc.c dm_ipc.h dm_log_report.c dm_manager.c dm_manager.h dm_message.c dm_message.h dm_message_cache.c dm_message_cache.h dm_msg_process.c dm_msg_process.h dm_opt.c dm_opt.h dm_ota.c dm_ota.h dm_server.c dm_server.h dm_server_adapter.c dm_server_adapter.h dm_shadow.c dm_shadow.h dm_tsl_alink.c dm_tsl_alink.h dm_utils.c dm_utils.h dm_wrapper.h impl_gateway.c impl_gateway.h impl_linkkit.c impl_ntp.c impl_ntp.h impl_solo.c impl_solo.h iot_export_linkkit.h iotx_cm.c iotx_cm.h iotx_cm_coap.c iotx_cm_coap.h iotx_cm_internal.h iotx_cm_mqtt.c iotx_cm_mqtt.h iotx_dm.h iotx_dm_config.h iotx_dm_internal.h iotx_log_report.h linkkit_export.h linkkit_gateway_export.h
  group c-sdk/dev_sign
    c-sdk/dev_sign/: dev_sign_api.h dev_sign_internal.h dev_sign_mqtt.c dev_sign_wrapper.h
  group c-sdk/infra
    c-sdk/infra/: infra_cjson.c infra_cjson.h infra_compat.c infra_compat.h infra_config.h infra_defs.c infra_defs.h infra_list.h infra_log.c infra_log.h infra_net.c infra_net.h infra_report.c infra_report.h infra_sha256.c infra_sha256.h infra_string.c infra_string.h infra_timer.c infra_timer.h infra_types.h
  group c-sdk/mqtt
    c-sdk/mqtt/: iotx_mqtt_client.c iotx_mqtt_client.h iotx_mqtt_config.h mqtt_api.c mqtt_api.h mqtt_internal.h mqtt_wrapper.h MQTTConnect.h MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c
  group c-sdk/wrappers
    c-sdk/wrappers/: esp8266.c wrapper.c wrappers_defs.h
  group c-sdk/wrappers/external_libs
    c-sdk/wrappers/external_libs/: cJSON.c cJSON.h
  group c-sdk/wrappers/TLS
    c-sdk/wrappers/tls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h mpu_armv7.h mpu_armv8.h system_MIMXRT1052.c system_MIMXRT1052.h
  group component/kv
    component/kv/: kv.c kv_adapt.c kv_cli.c kv_secure.c kv_types.h
  group component/kv/include
    component/kv/include/: kv_adapt.h kv_api.h kv_conf.h kv_err.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: lpuart_adapter.c uart.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_xbara.c fsl_xbara.h
  group emgui
    emgui/: DeviceDriver.c DeviceDriver.h ewmain.c ewmain.h
  group emgui/GeneratedCode
    emgui/GeneratedCode/: _ApplicationApplication.h _CoreCursorEvent.h _CoreCursorGrabEvent.h _CoreCursorHit.h _CoreDialogContext.h _CoreDragEvent.h _CoreEvent.h _CoreGroup.h _CoreKeyEvent.h _CoreKeyPressHandler.h _CoreLayoutContext.h _CoreLayoutQuadContext.h _CoreModalContext.h _CoreOutline.h _CorePropertyObserver.h _CoreQuadView.h _CoreRectView.h _CoreResource.h _CoreRoot.h _CoreSimpleTouchHandler.h _CoreSlideTouchHandler.h _CoreSystemEvent.h _CoreSystemEventHandler.h _CoreSystemEventTask.h _CoreTask.h _CoreTaskQueue.h _CoreTimer.h _CoreVerticalList.h _CoreView.h _EffectsEffect.h _EffectsEffectTimerClass.h _EffectsInt32Effect.h _EffectsRectEffect.h _EffectsTimingList.h _GraphicsCanvas.h _ResourcesBitmap.h _ResourcesFont.h _ViewsBorder.h _ViewsFrame.h _ViewsImage.h _ViewsRectangle.h _ViewsText.h _WasherDeviceClass.h _WasherHourItemL.h _WasherHourItemS.h _WasherMinItemL.h _WasherMinItemS.h _WasherOptItemL.h _WasherOptItemS.h _WasherOptList.h _WasherProgItemL.h _WasherProgItemS.h _WasherProgList.h _WasherSpinItemL.h _WasherSpinItemS.h _WasherSpinList.h _WasherStartButton.h _WasherTempItemL.h _WasherTempItemS.h _WasherTempList.h _WasherTimeList.h _WasherWasher.h Application.c Application.h Core.c Core.h Effects.c Effects.h ewlocale.h Graphics.c Graphics.h Resources.c Resources.h Templates.c Templates.h Views.c Views.h Washer.c Washer.h
  group emgui/RGB565
    emgui/RGB565/: ewextgfx.c libewgfx-m7-iar.a
  group emgui/RTE
    emgui/RTE/: ewextrte.c libewrte-m7-iar.a
  group emgui/TargetSpecific
    emgui/TargetSpecific/: ew_bsp_clock.c ew_bsp_clock.h ew_bsp_display.c ew_bsp_display.h ew_bsp_event.c ew_bsp_event.h ew_bsp_graphics.c ew_bsp_graphics.h ew_bsp_inout.c ew_bsp_inout.h ew_bsp_serial.c ew_bsp_serial.h ew_bsp_system.c ew_bsp_system.h ew_bsp_touch.c ew_bsp_touch.h
  group emgui/TLSF
    emgui/TLSF/: tlsf.c tlsf.h tlsfbits.h
  group ESP8266
    ESP8266/: esp8266_at.c esp8266_at.h
  group lwip
    lwip/: CHANGELOG ChangeLogKSDK.txt CMakeLists.txt COPYING FEATURES FILES README UPGRADING
  group lwip/doc
    lwip/doc/: contrib.txt FILES mdns.txt mqtt_client.txt NO_SYS_SampleCode.c ppp.txt savannah.txt ZeroCopyRx.c
  group lwip/doc/doxygen
    lwip/doc/doxygen/: generate.bat generate.sh lwip.Doxyfile lwip.Doxyfile.cmake.in main_page.h
  group lwip/doc/doxygen/output
    lwip/doc/doxygen/output/: index.html
  group lwip/port
    lwip/port/: sys_arch.c
  group lwip/port/arch
    lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src
    lwip/src/: FILES
  group lwip/src/api
    lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/apps/lwiperf
    lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/core
    lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    lwip/src/include/lwip/apps/: lwiperf.h
  group lwip/src/include/lwip/priv
    lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c FILES lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c PPPD_FOLLOWUP pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c README sha1.c
  group mbedtls/include/mbedtls
    mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedtls/library
    mbedtls/library/: .gitignore aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c CMakeLists.txt ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c Makefile md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    mbedtls/port/ksdk/: aes_alt.c aes_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h
  group sdmmc/inc
    sdmmc/inc/: fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group sdmmc/src
    sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group source
    source/: app_preinclude.h esp_config.h FreeRTOSConfig.h lwipopts.h wiced_iperf.c
  group source/common_drivers
    source/common_drivers/: flexspi_hyper_flash_ops.c flexspi_hyper_flash_ops.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h ip_cmd.c ip_cmd.h shell.c shell.h virtual_com.c virtual_com.h
  group source/demo_dim
    source/demo_dim/: lighting.c
  group source/demo_rgb
    source/demo_rgb/: i2c.c pca9634.c rgb_light.c
  group source/demo_wm
    source/demo_wm/: washing_machine.c washing_machine.h
  group src
    src/: evkbimxrt1050.mac MIMXRT1052xxxxx_ram.icf
  group startup
    startup/: startup_MIMXRT1052.s
  group touchpanel
    touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group usb/device/class
    usb/device/: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    usb/device/: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/include
    usb/device/: usb_device.h
  group usb/device/source
    usb/device/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_descriptor.c
  group usb/device/source/ehci
    usb/device/: usb_device_ehci.c usb_device_ehci.h
    usb/include/: usb_ehci.h
  group usb/include
    usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/osa
    usb/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group usb/phy
    usb/phy/: usb_phy.c usb_phy.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
  group WiFi_ESP8266
    WiFi_ESP8266/ESP_AT_Lib/: LICENSE README.md
  group WiFi_ESP8266/ESP_AT_Lib/src/api
    WiFi_ESP8266/ESP_AT_Lib/src/api/: esp_netconn.c esp_rest_client.c
  group WiFi_ESP8266/ESP_AT_Lib/src/esp
    WiFi_ESP8266/ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mdns.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c
  group WiFi_ESP8266/ESP_AT_Lib/src/include/esp
    WiFi_ESP8266/ESP_AT_Lib/src/include/esp/: esp.h esp_ap.h esp_buff.h esp_cli.h esp_config_default.h esp_conn.h esp_debug.h esp_evt.h esp_hostname.h esp_includes.h esp_input.h esp_int.h esp_mdns.h esp_mem.h esp_netconn.h esp_parser.h esp_pbuf.h esp_ping.h esp_private.h esp_rest_client.h esp_sntp.h esp_sta.h esp_threads.h esp_timeout.h esp_typedefs.h esp_unicode.h esp_utilities.h esp_wps.h
  group WiFi_ESP8266/ESP_AT_Lib/src/include/system
    WiFi_ESP8266/ESP_AT_Lib/src/include/system/: esp_ll.h esp_sys.h esp_sys_freertos.h
  group WiFi_ESP8266/ESP_AT_Lib/src/system
    WiFi_ESP8266/ESP_AT_Lib/src/system/: esp_ll_imxrt.c esp_sys_freertos.c
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
